v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {nmos3.sym} 100 0 0 0 {name=X1 model=irf540 m=1}
